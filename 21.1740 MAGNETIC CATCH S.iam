# Autodesk Inventor assembly: 21.1740 MAGNETIC CATCH S
## iProperties
Created: 2007-03
Part Number: 21.1740 MAGNETIC CATCH S
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
